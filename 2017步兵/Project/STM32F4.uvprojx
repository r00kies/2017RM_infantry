# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Libraries;..\User;..\BSP;..\MPU6050;..\HMC5883;..\User\debug;..\IMU;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.c
  group MPU6050
    ../MPU6050/: mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c mpu6050_process.c
    ../IMU/: HMC5883L.c
  group BSP
    ../BSP/: bsp.c can1.c can2.c usart1.c delay.c tim6.c led.c laser.c usart2.c pwm.c stmflash.c buzzer.c ad.c encoder.c key.c usart3.c Iwdg.c RELAY.c
    ../Libraries/: stm32f4xx_iwdg.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_adc.c
  group UCOS_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOS_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group TASK
    ../TASK/: TASK_CONTROL.C TASK_CAN.C TASK_DBUG.C TASK_DOOR.C TASK_LED.C TASK_KEY_board.c
